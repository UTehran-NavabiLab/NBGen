* SPICE netlist generated by Yosys 0.36 (git sha1 8f07a0d8404, clang 15.0.0 -fPIC -Os)

X0 _84_ N108 _85_ AND2_X1
X1 _126_ N8 _60_ AND2_X1
X2 _37_ _40_ _62_ AND2_X1
X3 _44_ _45_ _67_ AND2_X1
X4 _37_ _40_ _47_ _43_ _46_ AND4_X1
X5 _49_ _52_ _59_ _55_ _58_ AND4_X1
X6 _7_ _60_ _61_ _127_ N14 AOI211_X1
X7 _90_ _123_ _117_ N112 AOI21_X1
X8 _31_ _36_ _126_ N34 AOI21_X1
X9 _2_ _39_ _126_ N21 AOI21_X1
X10 _119_ _42_ _126_ N60 AOI21_X1
X11 _27_ _45_ _126_ N47 AOI21_X1
X12 _22_ _50_ _126_ N99 AOI21_X1
X13 _13_ _54_ _126_ N86 AOI21_X1
X14 _18_ _56_ _126_ N73 AOI21_X1
X15 _61_ _128_ _47_ _59_ AOI21_X1
X16 N56 _71_ _73_ _72_ N95 AOI22_X1
X17 _26_ _28_ _33_ _30_ _32_ AOI22_X1
X18 _67_ _37_ _68_ _38_ _39_ AOI22_X1
X19 _74_ N4 _76_ _75_ N43 AOI22_X1
X20 N17 _77_ _79_ _78_ N30 AOI22_X1
X21 N69 _80_ _82_ _81_ N82 AOI22_X1
X22 _93_ _94_ _98_ _97_ _96_ AOI22_X1
X23 _100_ _101_ _102_ _86_ _70_ AOI22_X1
X24 _104_ _105_ _109_ _108_ _107_ AOI22_X1
X25 _111_ _112_ _116_ _115_ _114_ AOI22_X1
X26 _17_ _19_ _24_ _21_ _23_ AOI22_X1
X27 _125_ N223 BUF_X1
X28 _126_ N329 BUF_X1
X29 _127_ N370 BUF_X1
X30 _128_ N421 BUF_X1
X31 _129_ N430 BUF_X1
X32 _130_ N431 BUF_X1
X33 _131_ N432 BUF_X1
X34 N56 _69_ INV_X1
X35 N102 _84_ INV_X1
X36 _87_ _88_ INV_X1
X37 N43 _92_ INV_X1
X38 N82 _95_ INV_X1
X39 N69 _99_ INV_X1
X40 N4 _103_ INV_X1
X41 N17 _106_ INV_X1
X42 N95 _110_ INV_X1
X43 N30 _113_ INV_X1
X44 N115 _122_ INV_X1
X45 N50 _71_ INV_X1
X46 _0_ _1_ INV_X1
X47 _5_ _6_ INV_X1
X48 _11_ _12_ INV_X1
X49 _118_ _126_ INV_X1
X50 _47_ _129_ INV_X1
X51 _58_ _64_ INV_X1
X52 _89_ _125_ INV_X1
X53 N89 _72_ INV_X1
X54 N1 _74_ INV_X1
X55 N37 _75_ INV_X1
X56 N11 _77_ INV_X1
X57 N24 _78_ INV_X1
X58 N63 _80_ INV_X1
X59 N76 _81_ INV_X1
X60 _86_ _70_ _87_ NAND2_X1
X61 _101_ _100_ _16_ NAND2_X1
X62 _101_ N69 _18_ NAND2_X1
X63 _112_ _111_ _20_ NAND2_X1
X64 _112_ N95 _22_ NAND2_X1
X65 _94_ _93_ _25_ NAND2_X1
X66 _94_ N43 _27_ NAND2_X1
X67 _115_ _114_ _29_ NAND2_X1
X68 _115_ N30 _31_ NAND2_X1
X69 _35_ _36_ _37_ NAND2_X1
X70 _38_ _39_ _40_ NAND2_X1
X71 _86_ N56 _119_ NAND2_X1
X72 _41_ _42_ _43_ NAND2_X1
X73 _44_ _45_ _46_ NAND2_X1
X74 _48_ _123_ _49_ NAND2_X1
X75 _51_ _50_ _52_ NAND2_X1
X76 _53_ _54_ _55_ NAND2_X1
X77 _57_ _56_ _58_ NAND2_X1
X78 _43_ _46_ _63_ NAND2_X1
X79 _123_ _122_ _124_ NAND2_X1
X80 _108_ _107_ _0_ NAND2_X1
X81 _108_ N17 _2_ NAND2_X1
X82 _105_ _104_ _5_ NAND2_X1
X83 _105_ N4 _7_ NAND2_X1
X84 _97_ _96_ _11_ NAND2_X1
X85 _97_ N82 _13_ NAND2_X1
X86 _24_ _33_ _34_ _15_ NAND3_X1
X87 _37_ _46_ _66_ _55_ NAND3_X1
X88 _73_ _76_ _83_ _79_ _82_ NAND4_X1
X89 _98_ _102_ _117_ _109_ _116_ NAND4_X1
X90 _121_ _4_ _10_ _9_ _124_ NAND4_X1
X91 _64_ _37_ _65_ _43_ _46_ NAND4_X1
X92 _69_ N60 _70_ NOR2_X1
X93 _113_ N34 _114_ NOR2_X1
X94 _117_ _91_ _118_ NOR2_X1
X95 _119_ N66 _120_ NOR2_X1
X96 _2_ N27 _3_ NOR2_X1
X97 _7_ N14 _8_ NOR2_X1
X98 _13_ N92 _14_ NOR2_X1
X99 _18_ N79 _19_ NOR2_X1
X100 _22_ N105 _23_ NOR2_X1
X101 _27_ N53 _28_ NOR2_X1
X102 _31_ N40 _32_ NOR2_X1
X103 _83_ _85_ _89_ NOR2_X1
X104 _90_ N112 _91_ NOR2_X1
X105 _92_ N47 _93_ NOR2_X1
X106 _95_ N86 _96_ NOR2_X1
X107 _99_ N73 _100_ NOR2_X1
X108 _103_ N8 _104_ NOR2_X1
X109 _106_ N21 _107_ NOR2_X1
X110 _110_ N99 _111_ NOR2_X1
X111 _65_ _62_ _130_ _63_ _55_ OAI211_X1
X112 _65_ _68_ _131_ _52_ _66_ OAI211_X1
X113 N50 _86_ _83_ _85_ OAI21_X1
X114 _120_ _121_ _118_ _88_ OAI21_X1
X115 _3_ _4_ _118_ _1_ OAI21_X1
X116 _8_ _9_ _118_ _6_ OAI21_X1
X117 _14_ _15_ _118_ _12_ OAI21_X1
X118 _16_ _17_ _117_ _91_ OAI21_X1
X119 _20_ _21_ _117_ _91_ OAI21_X1
X120 _25_ _26_ _117_ _91_ OAI21_X1
X121 _29_ _30_ _117_ _91_ OAI21_X1
X122 N40 _35_ _34_ _10_ OAI21_X1
X123 N27 _38_ _34_ _10_ OAI21_X1
X124 N108 _90_ _89_ _84_ OAI21_X1
X125 N66 _41_ _34_ _10_ OAI21_X1
X126 N53 _44_ _34_ _10_ OAI21_X1
X127 N115 _48_ _34_ _10_ OAI21_X1
X128 N105 _51_ _34_ _10_ OAI21_X1
X129 N92 _53_ _34_ _10_ OAI21_X1
X130 N79 _57_ _34_ _10_ OAI21_X1
X131 N37 _94_ _83_ _85_ OAI21_X1
X132 N76 _97_ _83_ _85_ OAI21_X1
X133 N63 _101_ _83_ _85_ OAI21_X1
X134 N1 _105_ _83_ _85_ OAI21_X1
X135 N11 _108_ _83_ _85_ OAI21_X1
X136 N89 _112_ _83_ _85_ OAI21_X1
X137 N24 _115_ _83_ _85_ OAI21_X1
X138 _34_ _10_ _127_ OR2_X1

************************
* end of SPICE netlist *
************************
